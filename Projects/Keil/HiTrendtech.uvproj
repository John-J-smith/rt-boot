# Keil uVision project HiTrendtech.uvproj, settings and files
target HT501x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HT501x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: HT501x
  c misc: --C99
  c include: ..\..\Libraries\CMSIS\CM0\CoreSupport;..\..\Libraries\CMSIS\CM0\DeviceSupport;..\..\Libraries\CMSIS\CM0\DeviceSupport\inc;..\..\Libraries\HT60xx_StdPeriph_Driver;..\..\Libraries\HT60xx_StdPeriph_Driver\inc;..\..\Users;..\..\Users\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Libraries/CMSIS/CM0/DeviceSupport/src/: system_ht6xxx.c
  group Doc
    ../../Documents/: readme.txt
  group Example
    ../../Examples/aes/src/: aes_example.c
    ../../Examples/crc/src/: crc_example.c
    ../../Examples/ecc/src/: ecc_example.c
    ../../Examples/others/src/: example.c
    ../../Examples/flash/src/: flash_example.c
    ../../Examples/random/src/: random_example.c
  group Startup
    ../../Libraries/Startup/Keil/: startup_ht6x1x.s startup_ht6x2x.s startup_ht6x3x.s startup_ht501x.s startup_ht502x.s
  group StdPeriphDriver
    ../../Libraries/HT60xx_StdPeriph_Driver/src/: ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c ht501x_emu.c ht501x_keyscan.c ht6x3x_emu.c
  group CM
    ../../Users/CM/: CM.c modem_conf_protocol.c ota.c packet.c reallin_protocol.c
  group HD
    ../../Users/Driver/Flash/: HD_Flash.c
    ../../Users/Driver/GPIO/: HD_GPIO.c
    ../../Users/Driver/System/: HD_System.c
    ../../Users/Driver/UART/: HD_UART.c
  group INC
    ../../Users/inc/: Include.h
  group User
    ../../Users/: AL_Main.c main.c ht6xxx_it.c
  group MM_UAL
    ../../Users/MM_UAL/: MM_UAL.c
  group NB_IOT
    ../../Users/NB_IoT/: AT.c CoAP.c TCP.c UDP.c
  group Log
    ../../Users/log/: log.c
  group FreeRTOS
    ../../Users/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Users/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Users/FreeRTOS/portable/IAR/ARM_CM0/: port.c
target HT502x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HT502x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: HT502x
  c misc: --C99
  c include: ..\..\Libraries\CMSIS\CM0\CoreSupport;..\..\Libraries\CMSIS\CM0\DeviceSupport;..\..\Libraries\CMSIS\CM0\DeviceSupport\inc;..\..\Libraries\HT60xx_StdPeriph_Driver;..\..\Libraries\HT60xx_StdPeriph_Driver\inc;..\..\Users;..\..\Users\inc;..\..\Examples\aes\inc;..\..\Examples\crc\inc;..\..\Examples\ecc\inc;..\..\Examples\flash\inc;..\..\Examples\others\inc;..\..\Examples\random\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target HT6x1x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HT6x1x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: HT6x1x
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target HT6x2x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HT6x2x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: HT6x2x
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target HT6x3x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: S5VD-App +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: HT6x3x
  c misc: --C99
  c include: ..\..\Libraries\CMSIS\CM0\CoreSupport;..\..\Libraries\CMSIS\CM0\DeviceSupport;..\..\Libraries\CMSIS\CM0\DeviceSupport\inc;..\..\Libraries\HT60xx_StdPeriph_Driver;..\..\Libraries\HT60xx_StdPeriph_Driver\inc;..\..\Users;..\..\Users\inc;..\..\Users\MM_UAL;..\..\Users\CM;..\..\Users\Driver\Flash;..\..\Users\Driver\GPIO;..\..\Users\Driver\System;..\..\Users\Driver\UART;..\..\Users\FreeRTOS\include;..\..\Users\FreeRTOS\portable;..\..\Users\log;..\..\Users\NB_IoT;..\..\Users\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\config\HT6x3x\Objects\HT6x3x.sct
