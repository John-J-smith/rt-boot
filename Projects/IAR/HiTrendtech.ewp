# IAR project HiTrendtech.ewp, settings and files
configuration HT6x3x (ARM, debug)
  General.OGChipSelectEditMenu: HT6X3X Hitrendtech HT6X3X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HT6x3x; USE_TARGET_DRIVER; __TARGET_EWARM_USED
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM0\CoreSupport; ..\..\Libraries\CMSIS\CM0\DeviceSupport; ..\..\Libraries\CMSIS\CM0\DeviceSupport\inc; ..\..\Libraries\HT60xx_StdPeriph_Driver; ..\..\Libraries\HT60xx_StdPeriph_Driver\inc; ..\..\Users; ..\..\Users\inc; ..\..\Users\CM; ..\..\Users\Driver\Flash; ..\..\Users\Driver\GPIO; ..\..\Users\Driver\System; ..\..\Users\Driver\UART; ..\..\Users\FreeRTOS; ..\..\Users\FreeRTOS\include; ..\..\Users\FreeRTOS\portable\IAR\ARM_CM0; ..\..\Users\MM_UAL; ..\..\Users\NB_IoT; ..\..\Users\log; ..\..\Users\MM_UAL; ..\..\..\FreeRTOS; ..\..\Users\Driver\EEPROM; ..\..\Users\Driver\ADC; ..\..\Users\Src; ..\..\Users\Driver\m_Memory; ..\..\Users\sfud\inc; ..\..\Users\fal-latest\porting; ..\..\Users\fal-latest\inc; ..\..\Users\EasyFlash-master\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\FreeRTOS
  OBJCOPY.OOCOutputFile: BOOT-2021-107.hex
  ILINK.IlinkOutputFile: HT6X3X.out
  ILINK.IlinkIcfFile: flashloader\Hitrendtech\HT6X3X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HT6x2x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT6X2X Hitrendtech HT6X2X
  ICCARM.CCDefines: HT6x2x
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM0\CoreSupport; ..\..\Libraries\CMSIS\CM0\DeviceSupport; ..\..\Libraries\CMSIS\CM0\DeviceSupport\inc; ..\..\Libraries\HT60xx_StdPeriph_Driver; ..\..\Libraries\HT60xx_StdPeriph_Driver\inc; ..\..\Users; ..\..\Users\inc; ..\..\Users\CM; ..\..\Users\Driver\Flash; ..\..\Users\Driver\GPIO; ..\..\Users\Driver\System; ..\..\Users\Driver\UART; ..\..\Users\FreeRTOS; ..\..\Users\FreeRTOS\include; ..\..\Users\FreeRTOS\portable\IAR\ARM_CM0; ..\..\Users\MM_UAL; ..\..\Users\NB_IoT; ..\..\Users\log; ..\..\Users\MM_UAL; ..\..\..\FreeRTOS; ..\..\Users\Driver\EEPROM; ..\..\Users\Driver\ADC; ..\..\Users\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: BOOT-2010-105.hex
  ILINK.IlinkOutputFile: HT6X2X.out
  ILINK.IlinkIcfFile: flashloader\Hitrendtech\HT6X2X - 15k boot.icf
configuration HT6x1x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT6X1X Hitrendtech HT6X1X
  ICCARM.CCDefines: HT6x1x
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM0\CoreSupport; ..\..\Libraries\CMSIS\CM0\DeviceSupport; ..\..\Libraries\CMSIS\CM0\DeviceSupport\inc; ..\..\Libraries\HT60xx_StdPeriph_Driver; ..\..\Libraries\HT60xx_StdPeriph_Driver\inc; ..\..\Users; ..\..\Users\inc
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT6x1x.bin
  ILINK.IlinkOutputFile: HT6X1X.out
  ILINK.IlinkIcfFile: flashloader\HT6X1X.icf
configuration HT502x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT502X Hitrendtech HT502X
  ICCARM.CCDefines: HT502x
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT502x.bin
  ILINK.IlinkOutputFile: HT502X.out
  ILINK.IlinkIcfFile: flashloader\HT502X.icf
configuration HT501x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT501X Hitrendtech HT501X
  ICCARM.CCDefines: HT501x
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT501x.bin
  ILINK.IlinkOutputFile: HT501X.out
  ILINK.IlinkIcfFile: flashloader\HT501X.icf
  group CMSIS
    ../../Libraries/CMSIS/CM0/DeviceSupport/src/: system_ht6xxx.c
  group Startup
    ../../Libraries/Startup/IAR/: startup_ht501x.s startup_ht502x.s startup_ht6x1x.s startup_ht6x2x.s startup_ht6x3x.s
  group StdPeriphDriver
    ../../Libraries/HT60xx_StdPeriph_Driver/src/: ht501x_emu.c ht501x_keyscan.c ht6x3x_emu.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c
  group User
    ../../Users/: AL_main.c ht6xxx_it.c jump.s main.c
    ../../Users/inc/: Include.h
  group User/easyflash
    ../../Users/EasyFlash-master/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ../../Users/EasyFlash-master/ports/: ef_fal_port.c
  group User/fal
    ../../Users/fal-latest/src/: fal.c fal_flash.c fal_partition.c
    ../../Users/fal-latest/porting/: fal_cfg.h fal_eeprom_port.c fal_flash_ht6xxx_port.c fal_flash_sfud_port.c
  group User/HD
    ../../Users/Driver/EEPROM/: HD_EEPROM.c
    ../../Users/Driver/Flash/: HD_Flash.c
    ../../Users/Driver/GPIO/: HD_GPIO.c
    ../../Users/Driver/System/: HD_System.c
    ../../Users/Driver/UART/: HD_UART.c
    ../../Users/Driver/m_Memory/: m_Memory_V1.0.c
  group User/MM_UAL
    ../../Users/MM_UAL/: MM_UAL.c
  group User/sfud
    ../../Users/sfud/src/: sfud.c sfud_sfdp.c
    ../../Users/sfud/port/: sfud_port.c
  group User/src
    ../../Users/Src/: common.c common.h ota.c ota.h v_stdio.c
